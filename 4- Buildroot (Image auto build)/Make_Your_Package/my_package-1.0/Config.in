## 4- Buildroot (Image auto build)/Make_Your_Package/my_package-1.0/Config.in
```kconfig
config BR2_PACKAGE_MY_PACKAGE
    bool "my_package"
    help
      Hello World Package
```
